LICENSE = "CLOSED"

PORTAL_SRC = "${PROXIMOS_SRC}/portal"
require ${PORTAL_SRC}/packaging/fiber-portal.bb
