RDEPENDS:${PN} += "libubootenv-bin"
